# Keil uVision project test.uvproj, settings and files
target test (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE;..\SYS;D:\Keil_v5\C51\INC
  group START
    ./: STARTUP.A51
  group USER
    ../USER/: main.c
  group SYS
    ../SYS/: delay.c tim.c
  group HARDWARE
    ../HARDWARE/: led.c key.c seg.c
